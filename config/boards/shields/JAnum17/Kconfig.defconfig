## config/boards/shields/JAnum17/Kconfig.defconfig
```kconfig
if SHIELD_JANUM17

config ZMK_KEYBOARD_NAME
    default "JAnum17"

endif # SHIELD_JAnum17
```
